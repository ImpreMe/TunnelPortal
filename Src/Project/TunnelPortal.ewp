# IAR project TunnelPortal.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F103xE; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pe550
  ICCARM.CCIncludePath2: ..\App\CMSIS\Device\Include; ..\App\CMSIS\Include; ..\App\User; ..\App\BSP\Include; ..\App\FreeRTOSV10.0.0\Include; ..\App\CarCheck; ..\App\STM32F1xx_HAL_Driver\Inc; ..\App\DIDO; ..\App\SoftI2C; ..\App\EEPROM; ..\App\Light; ..\App\COMM; ..\App\Debug; ..\App\CRC; ..\App\Lora
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\App\User
  OBJCOPY.OOCOutputFile: TunnelPortal.srec
  ILINK.IlinkOutputFile: TunnelPortal.out
  ILINK.IlinkIcfFile: ..\App\CMSIS\Device\Source\Templates\iar\linker\stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group BSP/Include
    ../App/BSP/Include/: bsp.h bsp_can.h bsp_clock.h bsp_led.h bsp_spi.h bsp_usart.h
  group BSP/Source
    ../App/BSP/Source/: bsp.c bsp_can.c bsp_clock.c bsp_led.c bsp_spi.c bsp_usart.c
  group Check
    ../App/CarCheck/: check.c check.h
  group CMSIS
    ../App/CMSIS/Device/Source/Templates/iar/: startup_stm32f103xe.s
    ../App/CMSIS/Device/Include/: stm32f103xe.h stm32f1xx.h system_stm32f1xx.h
    ../App/CMSIS/Device/Source/Templates/: system_stm32f1xx.c
  group COMM
    ../App/COMM/: comm.c comm.h
  group CRC
    ../App/CRC/: CRC.h CRC16_IBM.c CRC32_IEEE.c CRC8_CCITT.c CRC8_PLC.c
  group Debug
    ../App/Debug/: debug.c debug.h
  group DIDO
    ../App/DIDO/: dido.c dido.h
  group EEPROM
    ../App/EEPROM/: EEPROM.c EEPROM.h EEPROM_port.h
  group FreeRTOS/Include
    ../App/FreeRTOSV10.0.0/Include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h portasm.s portmacro.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreeRTOS/Source
    ../App/FreeRTOSV10.0.0/Source/: croutine.c event_groups.c heap_2.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
  group Light
    ../App/Light/: Light.c Light.h
  group LoRa
    ../App/Lora/: platform.h radio.c radio.h sx1276-Fsk.c sx1276-Fsk.h sx1276-FskMisc.c sx1276-FskMisc.h sx1276-Hal.c sx1276-Hal.h sx1276-LoRa.c sx1276-LoRa.h sx1276-LoRaMisc.c sx1276-LoRaMisc.h sx1276.c sx1276.h
  group SoftI2C
    ../App/SoftI2C/: SoftI2C.c SoftI2C.h SoftI2C_port.c SoftI2C_port.h
  group STM32F1xx_HAL_Driver/inc
    ../App/STM32F1xx_HAL_Driver/Inc/: stm32f1xx_hal.h stm32f1xx_hal_adc.h stm32f1xx_hal_adc_ex.h stm32f1xx_hal_can.h stm32f1xx_hal_can_ex.h stm32f1xx_hal_cec.h stm32f1xx_hal_conf_template.h stm32f1xx_hal_cortex.h stm32f1xx_hal_crc.h stm32f1xx_hal_dac.h stm32f1xx_hal_dac_ex.h stm32f1xx_hal_def.h stm32f1xx_hal_dma.h stm32f1xx_hal_dma_ex.h stm32f1xx_hal_eth.h stm32f1xx_hal_flash.h stm32f1xx_hal_flash_ex.h stm32f1xx_hal_gpio.h stm32f1xx_hal_gpio_ex.h stm32f1xx_hal_hcd.h stm32f1xx_hal_i2c.h stm32f1xx_hal_i2s.h stm32f1xx_hal_irda.h stm32f1xx_hal_iwdg.h stm32f1xx_hal_mmc.h stm32f1xx_hal_nand.h stm32f1xx_hal_nor.h stm32f1xx_hal_pccard.h stm32f1xx_hal_pcd.h stm32f1xx_hal_pcd_ex.h stm32f1xx_hal_pwr.h stm32f1xx_hal_rcc.h stm32f1xx_hal_rcc_ex.h stm32f1xx_hal_rtc.h stm32f1xx_hal_rtc_ex.h stm32f1xx_hal_sd.h stm32f1xx_hal_smartcard.h stm32f1xx_hal_spi.h stm32f1xx_hal_sram.h stm32f1xx_hal_tim.h stm32f1xx_hal_tim_ex.h stm32f1xx_hal_uart.h stm32f1xx_hal_usart.h stm32f1xx_hal_wwdg.h stm32f1xx_ll_adc.h stm32f1xx_ll_bus.h stm32f1xx_ll_cortex.h stm32f1xx_ll_crc.h stm32f1xx_ll_dac.h stm32f1xx_ll_dma.h stm32f1xx_ll_exti.h stm32f1xx_ll_fsmc.h stm32f1xx_ll_gpio.h stm32f1xx_ll_i2c.h stm32f1xx_ll_iwdg.h stm32f1xx_ll_pwr.h stm32f1xx_ll_rcc.h stm32f1xx_ll_rtc.h stm32f1xx_ll_sdmmc.h stm32f1xx_ll_spi.h stm32f1xx_ll_system.h stm32f1xx_ll_tim.h stm32f1xx_ll_usart.h stm32f1xx_ll_usb.h stm32f1xx_ll_utils.h stm32f1xx_ll_wwdg.h
  group STM32F1xx_HAL_Driver/src
    ../App/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_msp_template.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_timebase_rtc_alarm_template.c stm32f1xx_hal_timebase_tim_template.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_adc.c stm32f1xx_ll_crc.c stm32f1xx_ll_dac.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_gpio.c stm32f1xx_ll_i2c.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_rtc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_usb.c stm32f1xx_ll_utils.c
  group User
    ../App/User/: AppHook.c FreeRTOSConfig.h includes.h main.c monitor.c monitor.h stm32f1xx_hal_conf.h
